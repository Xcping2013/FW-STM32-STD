# Keil uVision project stm32f030f4_16_4.uvprojx, settings and files
target stm32f030f4 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FW-MBOAKPLED-01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\BME280_driver-master;..\STM32F0xx_StdPeriph_Driver\inc;..\User;..\BME280_driver-master;..\BME280_driver-master\selftest;..\Project;..\Project\OKOA_LED_Test;..\bsp;..\Boards;..\Drivers;..\Boards\INC-MBVBUSRELAY4;..\Boards\INC_MBOAKPLED-01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Libraries
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_exti.c
  group BSP
    ../User/: uart1.c delay.c
    ../bsp/: bsp_eeprom_24xx.c bsp_i2c_gpio.c
  group drivers_led_driver
    ../bsp/: bsp_tlc5973.c
  group User
    ../User/: main.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030.s
  group user_test
    ../Project/: user_test.c
  group LCOM_CABLE_TEST
    ../Project/: lcomp_e75_test.c pcm1.c
  group OKOA_LED_Test
    ../Project/OKOA_LED_Test/: OKOA_LED_Test.c
    ../bsp/: app1_i2c_eeprom.c app_tlc5973.c
  group INC_MBAD9834
    ../Drivers/: AD9834.c MCP42010.c
    ../Boards/: INC_MBAD9834.c
  group INC-MBVBUSRELAY
    ../Boards/: INC-MBVBUSRELAY.c
  group INC-MBDIOCN1-01
    ../Boards/: INC-MBDIOCN1.c
  group INC-MBVBUSRELAY4
    ../Boards/INC-MBVBUSRELAY4/: INC-MBVBUSRELAY4.c
  group INC_MBOAKPLED-01
    ../Boards/INC_MBOAKPLED-01/: INC_MBOAKPLED-01.c
