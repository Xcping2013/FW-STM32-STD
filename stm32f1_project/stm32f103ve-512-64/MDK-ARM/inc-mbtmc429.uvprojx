# Keil uVision project inc-mbtmc429.uvprojx, settings and files
target dio16_3axis_controller (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: inc_mbtmc429_user_361 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib;..\STM32F10x_FWLib\inc;..\drivers\bsp_mcu;..\drivers\user_sys_app;..\drivers\eeprom;..\drivers\motor_controller;..\drivers\mcu_system_config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inculde
    ../drivers/io expand/: bsp_pca9539a.h
    ../drivers/bsp_mcu/: bsp_defines.h bsp_mcu_systick.h bsp_mcu_delay.h bsp_mcu_gpio.h bsp_mcu_softi2c.h bsp_mcu_timer.h bsp_mcu_spi.h bsp_mcu_uart.h bsp_mcu_exti.h
    ../drivers/eeprom/: bsp_eeprom_24xx.h app_eeprom_24xx.h
    ../drivers/motor_controller/: bsp_motor_tmc429.h
    ../drivers/user_sys_app/: app_gpio_dido.h app_sys_control.h app_button.h
  group system_config
    ../drivers/mcu_system_config/: stm32f10x_it.c system_stm32f10x.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_exti.c
    ../STM32F10x_FWLib/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ../Doc/: PinSet.txt readme.txt
  group user_sys_bsp
    ../drivers/eeprom/: bsp_eeprom_24xx.c
    ../drivers/motor_controller/: bsp_motor_tmc429.c
  group bsp_mcu
    ../drivers/bsp_mcu/: bsp_mcu_systick.c bsp_mcu_delay.c bsp_mcu_gpio.c bsp_mcu_softi2c.c bsp_mcu_uart.c bsp_mcu_spi.c bsp_mcu_timer.c bsp_mcu_exti.c
  group user_sys_app
    ../drivers/user_sys_app/: inc_mbtmc429.c app_gpio_dido.c app_button.c app_motor_tmc429.c app_motor_home.c app_serial.c app_sys_control.c app_task_tick.c
    ../drivers/eeprom/: app_eeprom_24xx.c
  group ChangeList
    ../Doc/: ChangeLists.c
  group io expand
    ../drivers/io expand/: bsp_pca9539a.c app_pca9539a_dido.c
